# Keil uVision project Experiment2.uvproj, settings and files
target Target 1 (MCS-51)
  device: P80/P87C51X2 NXP (founded by Philips)
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: Experiment2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Experiment2.c
