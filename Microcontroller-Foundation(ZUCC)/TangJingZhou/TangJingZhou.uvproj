# Keil uVision project TangJingZhou.uvproj, settings and files
target Target 1 (MCS-51)
  device: P80/P87C52X2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: TangJingZhou +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 TangJingZhou.c
